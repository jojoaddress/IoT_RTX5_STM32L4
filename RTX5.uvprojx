# Keil uVision project RTX5.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: RTX5
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-invalid-source-encoding -Wno-pointer-sign
  c include: .\src;.\LIB\inc;.\COMM;.\SYSTEM;.\COMM\wifi_emw3080
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source
    ./src/: 2task.c app_main.c LED.c HTS221_IIC_Device.c HTS221_IIC_GPIO.c HTS221_IIC_Driver.c usart3.c tim.c gpio.c CC811.C beep.c Timer.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
  group LIB
    ./LIB/: transport.c lib.lib mqtt.lib serial.lib wifi.lib
  group COMM
    ./COMM/: serial_port.c
    ./COMM/wifi_emw3080/: bsp_wifi.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, CMSIS Driver:I2C 1.0.0, Device:STM32Cube HAL:Common 1.12.0, Device:STM32Cube HAL:Cortex 1.12.0, Device:STM32Cube HAL:DMA 1.12.0, Device:STM32Cube HAL:GPIO 1.12.0, Device:STM32Cube HAL:I2C 1.12.0, Device:STM32Cube HAL:IRDA 1.12.0, Device:STM32Cube HAL:PWR 1.12.0, Device:STM32Cube HAL:RCC 1.12.0, Device:STM32Cube HAL:Smartcard 1.12.0, Device:STM32Cube HAL:TIM 1.12.0, Device:STM32Cube HAL:UART 1.12.0, Device:STM32Cube HAL:USART 1.12.0, Device:Startup 1.3.1
